# Keil uVision project Task3_YawPID.uvprojx, settings and files
target Task3_YawPID (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Task3_YawPID +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER STM32F103xB
  c include: ..\Core\Inc;..\App\Inc;..\Drivers\STM32F1xx_HAL_Driver\Inc;..\Drivers\STM32F1xx_HAL_Driver\Inc\Legacy;..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\Drivers\CMSIS\Include
  asm define: USE_HAL_DRIVER STM32F103xB
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ./: startup_stm32f103xb.s
  group CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group HAL
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_i2c.c
  group Core
    ../Core/Src/: main.c gpio.c usart.c i2c.c tim.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group App
    ../App/Src/: app.c app_ctl.c app_pid.c app_yaw.c app_tb6612.c app_enc.c app_key.c app_led.c app_mpu6050.c app_i2c_bus.c app_vofa.c app_cli.c app_log.c app_util.c
    ../App/Inc/: app_mpu6050_reg.h
